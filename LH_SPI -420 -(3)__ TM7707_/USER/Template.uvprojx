# Keil uVision project Template.uvprojx, settings and files
target Template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tt +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\Hardware\24CXX;..\Hardware\CAN;..\Hardware\KEY;..\Hardware\IIC;..\Hardware\LED;..\Hardware\SPI;..\Hardware\WDG;..\USMART;..\FWLib\inc;..\Hardware\TIMER;..\Hardware\SETCS;..\Hardware\SPI;..\Hardware\AD1239;..\Hardware\MALLOC;..\Hardware\MODBUS
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group README
    ../: README.TXT
  group Hardware
    ../Hardware/CAN/: can.c
    ../Hardware/IIC/: myiic.c
    ../Hardware/KEY/: key.c
    ../Hardware/WDG/: wdg.c
    ../Hardware/TIMER/: timer.c
    ../Hardware/SETCS/: gui.c oled.c pic.c iic.c setcs.c
    ../Hardware/LED/: led.c
    ../Hardware/SPI/: spi.c
    ../Hardware/24CXX/: 24c64.c
    ../Hardware/AD1239/: TM7707.c
  group FWLib
    ../FWLib/src/: stm32f10x_usart.c misc.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_pwr.c stm32f10x_bkp.c
  group MODBUS
    ../Hardware/MALLOC/: malloc.c
    ../Hardware/MODBUS/: mcheck.c mport.c protocol.c
